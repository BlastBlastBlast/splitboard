## config/boards/shields/Kconfig.shield
```kconfig
config SHIELD_8-D_LEFT
    def_bool $(shields_list_contains,8-D_left)

config SHIELD_8-D_RIGHT
    def_bool $(shields_list_contains,8-D_right)
```
